# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\24c02;.\App\iic;.\App\key;.\App\smg;.\Public;.\App\ds18b20;.\App\ds1302;.\App\ired;.\App\time;.\App\xpt2046;.\App\pwm;.\App\lcd1602
  group User
    ./User/: main.c
    ./: ired.c AT24C02.c AT24C02.h I2C.c I2C.h TIMER0.c TIMER0.h TIMER1.c TIMER1.h
  group App
    ./: key .c key.h lcd1602.c mkey.h mkey.c Delay.c Delay.h beep.c beep.h
  group Public
    ./Public/: public.c
